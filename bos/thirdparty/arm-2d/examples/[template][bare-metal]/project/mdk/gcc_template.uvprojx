# Keil uVision project gcc_template.uvprojx, settings and files
target STM32F746G-Discovery-GCC (6160000::V6.16::ARMCLANG)
  device: STM32L431CBTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: gcc_template
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Application
    ../../: app_cfg.h main.c virtual_resource_demo.c virtual_resource_demo.h
  group Platform
    ./RTE/Device/STM32F746NGHx/: system_stm32f7xx.c
    ../../../common/platform/: app_platform.c platform.h
    ../../../common/platform/stm32f746g-discovery/: GLCD_746G_Discovery.c platform_stm32f746g_discovery.c startup_ARMCM7.c
  group asset
    ../../../common/asset/: helium.c
software components: Acceleration:Arm-2D Extras:Controls 1.3.5, Acceleration:Arm-2D Extras:LCD ASCII Printf 1.3.1, Acceleration:Arm-2D Helper:Display Adapter 1.5.7, Acceleration:Arm-2D Helper:PFB 1.5.5, Acceleration:Arm-2D Helper:Scene 1.1.6, Acceleration:Arm-2D:Alpha-Blending 1.1.2-dev, Acceleration:Arm-2D:Core 1.1.2-dev, Acceleration:Arm-2D:Transform 1.1.2-dev, CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.3, Utilities:perf_counter:Core 2.1.0, Board Support:Drivers:SDRAM 1.1.1, CMSIS Driver:USART 1.19.0, Device:STM32Cube Framework:Classic 1.3.0, Device:STM32Cube HAL:Common 1.3.0, Device:STM32Cube HAL:Cortex 1.3.0, Device:STM32Cube HAL:DMA 1.3.0, Device:STM32Cube HAL:GPIO 1.3.0, Device:STM32Cube HAL:LTDC 1.3.0, Device:STM32Cube HAL:PWR 1.3.0, Device:STM32Cube HAL:RCC 1.3.0, Device:STM32Cube HAL:SDRAM 1.3.0, Device:STM32Cube HAL:USART 1.3.0, Device:STM32Cube LL:Common 1.3.0, Device:STM32Cube LL:PWR 1.3.0, Device:STM32Cube LL:RCC 1.3.0, Device:STM32Cube LL:USART 1.3.0, Device:STM32Cube LL:UTILS 1.3.0, Device:Startup 1.2.5
